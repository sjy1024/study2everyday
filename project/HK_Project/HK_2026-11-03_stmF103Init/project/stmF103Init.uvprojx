# Keil uVision project stmF103Init.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32Init
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\cmsis;..\user;..\STM32F10x_StdPeriph_Driver\inc;..\STM32F10x_StdPeriph_Driver\src;..\api
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group uesr
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c
  group cmsis
    ../cmsis/: core_cm3.h startup_stm32f10x_hd.s stm32f10x.h
  group lib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
software components: CMSIS:CORE 6.2.0
